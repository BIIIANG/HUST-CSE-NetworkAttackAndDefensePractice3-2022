# Keil uVision project task3_1.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: CMSDK_CM4_FP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.1
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: task3_1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\RTE\Device\CMSDK_CM4_FP\ac6_arm.sct
  group Source Group 1
    ./Src/: task3.c task3a.h
    C:/Users/86131/Desktop/NADP3/KEIL/task3_1/Src/: task3a.lib
software components: CMSIS:CORE 5.6.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Board Support:Common 2.0.0, CMSIS Driver:USART 1.0.3, Device:Startup 1.1.0
